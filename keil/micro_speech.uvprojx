# Keil uVision project micro_speech.uvprojx, settings and files
target micro_speech (6090000::V6.9::.\ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: micro_speech
  AfterMake: fromelf --bin --output bin\micro_speech.bin bin\micro_speech.axf
  AfterMake: fromelf -cedrst --output bin\micro_speech.txt bin\micro_speech.axf
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 keil TF_LITE_STATIC_MEMORY NDEBUG
  c misc: -DTF_LITE_STATIC_MEMORY
  c include: ../src;../../../../../mcu/apollo3;../../../../..;../../../../../utils;../../../../../CMSIS/ARM/Include;../../../../../CMSIS/AmbiqMicro/Include;../../../../../devices;../../../bsp;../../../../../../../../../../../../../;../../../../../../flatbuffers/include;../../../../../../kissfft;../../../../../../gemmlowp
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\micro_speech.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../../../../../../../../../examples/micro_speech/: main.cc
    ../../../../../../../../../apollo3evb/: debug_log.cc
    ../../../../../../../../../examples/micro_speech/apollo3evb/: audio_provider.cc command_responder.cc
  group utils
    ../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c am_util_faultisr.c
  group keil
    ./: startup_keil6.c
  group lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
  group devices
    ../../../../../devices/: am_devices_led.c
  group c
    ../../../../../../../../../../../c/: c_api_internal.c
  group kernels
    ../../../../../../../../../kernels/: all_ops_resolver.cc fully_connected.cc softmax.cc conv.cc elementwise.cc pooling.cc
    ../../../../../../../../../../../kernels/: kernel_util.cc
    ../../../../../../../../../../../kernels/internal/: quantization_util.cc
  group api
    ../../../../../../../../../../../core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc
  group kissfft
    ../../../../../../kissfft/tools/: kiss_fftr.c
    ../../../../../../kissfft/: kiss_fft.c
  group example_micro_speech
    ../../../../../../../../../examples/micro_speech/: feature_provider.cc recognize_commands.cc
  group micro
    ../../../../../../../../../: debug_log_numbers.cc micro_error_reporter.cc micro_interpreter.cc micro_mutable_op_resolver.cc simple_tensor_allocator.cc
  group micro_features
    ../../../../../../../../../examples/micro_speech/micro_features/: no_micro_features_data.cc tiny_conv_micro_features_model_data.cc yes_micro_features_data.cc micro_features_generator.cc micro_model_settings.cc fft.cc fft_util.cc filterbank.cc filterbank_util.cc frontend.cc frontend_util.cc log_lut.cc log_scale.cc log_scale_util.cc noise_reduction.cc noise_reduction_util.cc pcan_gain_control.cc pcan_gain_control_util.cc window.cc window_util.cc
  group kernels_opt
    ../../../../../../../../../kernels/portable_optimized/: depthwise_conv.cc
